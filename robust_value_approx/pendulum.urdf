Commit message: framework to learn stable dynamics

File: robust_value_approx/pendulum.urdf (robot description, URDF)
Before this commit: robot physics, 2 links, 1 joints
Links:
- link pole: geometry visual box size=0.15 0.15 1.0
