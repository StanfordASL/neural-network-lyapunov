Commit message: working demo with panda

File: robust_value_approx/test/ball_panda_description/ball.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link base: geometry collision sphere radius=0.001; visual sphere radius=0.025
